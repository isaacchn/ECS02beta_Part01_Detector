# Keil uVision project TransTempByCan2SlaveSCM.uvproj, settings and files
target TransTempByCan2SlaveSCM (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: TransTempByCan2SlaveSCM +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source
    ./: ds18b20.c MCP2515.c Main.c DHT11.c
  group Head
    ./: ds18b20.h MCP2515.h DHT11.h
